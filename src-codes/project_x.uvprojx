# Keil uVision project project_x.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project_x +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: main.c UAART0.c uart.h SSP0.c SSP0.h RC522_RFID.c RC522_RFID.h LCD.c LCD.h DHT11.c DHT11.h DEALY.c DELAY.h MQ135.c MQ135.h globals.h globals.c
software components: CMSIS:CORE 6.1.1, Device:Startup 1.0.0
